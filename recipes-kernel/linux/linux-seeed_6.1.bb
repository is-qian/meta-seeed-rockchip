require linux-seeed-rockchip.inc
